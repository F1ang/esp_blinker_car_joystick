# IAR project YSF4_FOC-014. FOC_v5.2.0_42PMSM_HALLSensor.ewp, settings and files
configuration YSF4_FOC-014. FOC_v5.2.0_42PMSM_HALLSensor (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/Any/Inc; ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/F4xx/Inc; ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/UILibrary/Inc; ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/SystemDriveParams; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Inc\bsp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: YSF4_FOC-014. FOC_v5.2.0_42PMSM_HALLSensor.hex
  ILINK.IlinkOutputFile: YSF4_FOC-014. FOC_v5.2.0_42PMSM_HALLSensor.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/bsp/key/: bsp_key.c
    ../Src/: main.c mc_api.c mc_config.c mc_parameters.c mc_tasks.c motorcontrol.c regular_conversion_manager.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_mc_it.c ui_task.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/MotorControl
    ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/Any/Src/: circle_limitation.c hall_speed_pos_fdbk.c mc_interface.c mc_irq_handler.c mc_math.c motor_power_measurement.c open_loop.c pid_regulator.c pwm_common.c pwm_curr_fdbk.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c
    ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/F4xx/Src/: r3_f4xx_pwm_curr_fdbk.c
    ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/UILibrary/Src/: usart_frame_communication_protocol.c
