# Keil uVision project YSF4_FOC-014. FOC_v5.2.0_42PMSM_HALLSensor.uvprojx, settings and files
target YSF4_FOC-014. FOC_v5.2.0_42PMSM_HALLSensor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: YSF4_FOC-014. FOC_v5.2.0_42PMSM_HALLSensor +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/F4xx/Inc;../MCSDK_v5.2.0-Full/MotorControl/MCSDK/UILibrary/Inc;../MCSDK_v5.2.0-Full/MotorControl/MCSDK/SystemDriveParams;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Inc\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c mc_config.c mc_tasks.c stm32f4xx_mc_it.c mc_parameters.c ui_task.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Src/bsp/key/: bsp_key.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/Any/Src/: circle_limitation.c hall_speed_pos_fdbk.c mc_math.c mc_interface.c pid_regulator.c pwm_curr_fdbk.c pwm_common.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c
    ../MCSDK_v5.2.0-Full/MotorControl/MCSDK/MCLib/F4xx/Src/: r3_f4xx_pwm_curr_fdbk.c
software components: CMSIS:CORE 4.3.0
