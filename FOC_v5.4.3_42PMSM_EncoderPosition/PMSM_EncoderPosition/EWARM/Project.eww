<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\YS-F4_FOC-020. FOC_v5.4.3_42PMSM_EncoderPosition.ewp</path>
  </project>
  <batchBuild />
</workspace>
