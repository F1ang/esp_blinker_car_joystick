<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\YSF4_FOC-015. FOC_v5.2.0_42PMSM_Ecoder.ewp</path>
  </project>
  <batchBuild />
</workspace>
