<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\YSF4_FOC-011. FOC_v5.2.0_57BLDC_HALLSensor.ewp</path>
  </project>
  <batchBuild />
</workspace>
